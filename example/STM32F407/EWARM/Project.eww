<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AUART_F407.ewp</path>
  </project>
  <batchBuild />
</workspace>
